# Keil uVision project atk_f407.uvprojx, settings and files
target FreeRTOS (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: atk_f407 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ..\..\User;..\..\Drivers;..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\Drivers\CMSIS\Include;..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\Middlewares;..\..\Middlewares\FreeRTOS\include;..\..\Middlewares\FreeRTOS\portable\RVDS\ARM_CM4F;..\..\Drivers\BSP\OLED;..\..\Drivers\BSP\GPIO;..\..\Drivers\BSP\ENCODER;..\..\Drivers\BSP\PWM;..\..\Drivers\BSP\MOTO;..\..\Drivers\BSP\PID;..\..\Drivers\BSP\CONTROL;..\..\Drivers\BSP\ADC;..\..\Drivers\BSP\MPU6050;..\..\Drivers\BSP\MPU6050\eMPL;..\..\Drivers\BSP\SPI;..\..\Drivers\BSP\NRF24L01;..\..\Drivers\BSP\FuzzyPid;..\..\Drivers\BSP\HWT101;..\..\Drivers\BSP\Software_LCD3.5
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Startup
    ../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
  group User
    ../../User/: main.c stm32f4xx_it.c freertos_demo.c
    ../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Drivers/SYSTEM
    ../../Drivers/SYSTEM/delay/: delay.c
    ../../Drivers/SYSTEM/sys/: sys.c
    ../../Drivers/SYSTEM/usart/: usart.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_usart.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_sram.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c
  group Drivers/BSP
    ../../Drivers/BSP/LED/: led.c
    ../../Drivers/BSP/KEY/: key.c
    ../../Drivers/BSP/SRAM/: sram.c
    ../../Drivers/BSP/TIMER/: btim.c
    ../../Drivers/BSP/OLED/: oled.c
    ../../Drivers/BSP/GPIO/: gpio.c
    ../../Drivers/BSP/ENCODER/: encoder.c
    ../../Drivers/BSP/PWM/: pwm.c
    ../../Drivers/BSP/MOTO/: moto.c
    ../../Drivers/BSP/PID/: pid.c
    ../../Drivers/BSP/CONTROL/: control.c
    ../../Drivers/BSP/ADC/: adc.c
    ../../Drivers/BSP/FuzzyPid/: fuzzypid.c
  group Middlewares/MALLOC
    ../../Middlewares/MALLOC/: malloc.c
  group Middlewares/XMRAM
    ../../Middlewares/XMRAM/: XMRAM.h XMRAM.lib
  group Middlewares/FreeRTOS_CORE
    ../../Middlewares/FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Middlewares/FreeRTOS_PORT
    ../../Middlewares/FreeRTOS/portable/MemMang/: heap_4.c
    ../../Middlewares/FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
  group Drivers/BSP/HWT101
    ../../Drivers/BSP/HWT101/: HWT101.c wit_c_sdk.c
  group Drivers/BSP/LCD3.5
    ../../Drivers/BSP/Software_LCD3.5/: GUI.c lcd.c SPI.c test.c
  group Readme
    ../../: readme.txt
  group MPU6050
    ../../Drivers/BSP/MPU6050/: mpu6050.c myiic.c
    ../../Drivers/BSP/MPU6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
  group NRF24L01
    ../../Drivers/BSP/SPI/: spi.c
    ../../Drivers/BSP/NRF24L01/: nrf24l01.c
    ../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_spi.c
