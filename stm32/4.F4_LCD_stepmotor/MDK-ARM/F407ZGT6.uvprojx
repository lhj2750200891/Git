# Keil uVision project F407ZGT6.uvprojx, settings and files
target F407ZGT6 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: F407ZGT6 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: MPL_LOG_NDEBUG=1,MPU6050,EMPL,USE_DMP,EMPL_TARGET_STM32F4,USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Hardware/KEY;../Hardware/LED;../Hardware;../Hardware/TB6612;../Hardware/PID;../Hardware/TIMER;../Hardware/Hardware_MPU6050;../System/Delay;../System/Sys;../Hardware/OLED;../Hardware/Software_LCD3.5;..\Hardware\StepMotor
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c dma.c i2c.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Hardware
    ../Hardware/KEY/: KEY.c
    ../Hardware/LED/: LED.c
    ../Hardware/TIMER/: timer.c
    ../Hardware/TB6612/: TB6612.c
    ../Hardware/PID/: PID.c
    ../Hardware/OLED/: oled.c
  group Hardware/Hardware_MPU6050
    ../Hardware/Hardware_MPU6050/: inv_mpu.c inv_mpu_dmp_motion_driver.c mpu6050.c
  group Hardware/Software_LCD3.5
    ../Hardware/Software_LCD3.5/: GUI.c lcd.c SPI.c test.c
  group Hardware/stepmotor
    ../Hardware/StepMotor/: stepper_motor.c stepper_tim.c
  group System
    ../System/Delay/: Delay.c
    ../System/Sys/: sys.c
software components: CMSIS:CORE 4.3.0
